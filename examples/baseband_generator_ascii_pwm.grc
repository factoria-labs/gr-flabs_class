options:
  parameters:
    author: paul
    generate_options: qt_gui
    id: baseband_generator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: preamble_sync
  id: variable
  parameters:
    value: 8 * "01" + "0010" + "1101" + "1101" + "0100"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: preamble_sync
    tagname: payload_start
    threshold: '0'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: flabs_class_baseband_gen_0
  id: flabs_class_baseband_gen
  parameters:
    checksum_enable: '0'
    checksum_offset: '0'
    encode_one: (0, 1, 1)
    encode_zero: (0, 0, 1)
    pad_byte_count: '2'
    payloads: ("Hello USRP   ", "Hello HackRF ", "Hello Pluto  ", "Hello BladeRF", "Hello RTLSDR ")
    preamble_bit_count: '16'
    sync_word: 2dd4
    tx_spacing: '1'
  states: {}
- name: flabs_class_message_print_0
  id: flabs_class_message_print
  parameters:
    display_ascii: '2'
  states: {}
- name: flabs_class_pdu_decode_0
  id: flabs_class_pdu_decode
  parameters:
    one_seq: (0, 1, 1)
    zero_seq: (0, 0, 1)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Input BB"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Demod Out"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '39'
    sync: preamble_sync
    threshold: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_rx_chan
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_rx_chan
  states: {}

connections:
- [blocks_packed_to_unpacked_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_gfsk_demod_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_gfsk_mod_0, '0', virtual_sink_0, '0']
- [flabs_class_baseband_gen_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [flabs_class_pdu_decode_0, out, flabs_class_message_print_0, msg_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [satellites_sync_to_pdu_packed_0, out, flabs_class_pdu_decode_0, in]
- [virtual_source_0, '0', digital_gfsk_demod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
