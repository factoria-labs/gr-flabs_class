options:
  parameters:
    author: paul
    generate_options: qt_gui
    id: baseband_generator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: flabs_class_baseband_gen_0
  id: flabs_class_baseband_gen
  parameters:
    checksum_enable: '0'
    checksum_offset: '0'
    encode_one: (1, )
    encode_zero: (0, )
    pad_byte_count: '2'
    payloads: ("Hello USRP   ", "Hello HackRF ", "Hello Pluto  ", "Hello BladeRF", "Hello RTLSDR ")
    preamble_bit_count: '16'
    sync_word: 2dd4
    tx_spacing: '1'
  states: {}
- name: flabs_class_message_print_0
  id: flabs_class_message_print
  parameters:
    display_ascii: '2'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '13'
    sync: 8 * "01" + "0010" + "1101" + "1101" + "0100"
    threshold: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_rx_chan
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_rx_chan
  states: {}

connections:
- [digital_gfsk_demod_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_gfsk_mod_0, '0', virtual_sink_0, '0']
- [flabs_class_baseband_gen_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [satellites_sync_to_pdu_packed_0, out, flabs_class_message_print_0, msg_in]
- [virtual_source_0, '0', digital_gfsk_demod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
